# Keil uVision project Ultrasonic.uvproj, settings and files
target Target 1 (MCS-51)
  device: AT89C52 Microchip
  cpu: IRAM(0-0xFF) IROM(0-0x1FFF) CLOCK(24000000)
  output: Ultrasonic +hex
  c flags: Optimize=8 SizeSpeed=1
  group Source Group 1
    ./: STARTUP.A51 lcd1602.c lcd1602.h main.c public.c public.h Ultrasonic.h Ultrasonic.c standaloneKey.c standaloneKey.h
